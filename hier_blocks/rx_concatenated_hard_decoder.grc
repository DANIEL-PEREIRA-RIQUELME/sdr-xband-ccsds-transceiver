options:
  parameters:
    author: Daniel Pereira Riquelme
    generate_options: hb
    id: rx_concatenated_hard_decoder
    output_language: python
    title: Receiver (concatenated hard decoder)
  states: {}

blocks:
- name: constel
  id: variable_constellation
  parameters:
    const_points: digital.psk_4()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: soft_decision_precision
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_4()[1]
    type: calcdist
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2.0'
    type: float
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constel
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: loop_bw_costas
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: loop_bw_sync
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: loop_bw_costas
  id: parameter
  parameters:
    value: 2*3.14159/1000
  states: {}
- name: loop_bw_sync
  id: parameter
  parameters:
    value: '0.06'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_sink_0_0_0
  id: pad_sink
  parameters:
    label: sync_out
    type: complex
  states: {}
- name: pad_sink_0_0_1
  id: pad_sink
  parameters:
    label: Costas_out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: rolloff
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: rolloff
    decim: '1'
    gain: '1'
    ntaps: '32'
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_ccf
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    value: '25000000'
  states: {}
- name: satellites_ccsds_concatenated_deframer_0_0
  id: satellites_ccsds_concatenated_deframer
  parameters:
    convolutional: '"CCSDS"'
    frame_size: '223'
    precoding: None
    rs_basis: '"dual"'
    rs_interleaving: '1'
    scrambler: '"CCSDS"'
    threshold: '0'
  states: {}
- name: soft_decision_precision
  id: parameter
  parameters:
    value: '8'
  states: {}
- name: sps
  id: parameter
  parameters:
    value: '2'
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', satellites_ccsds_concatenated_deframer_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0_0, '0', pad_sink_0_0_1, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_symbol_sync_xx_0, '0', pad_sink_0_0_0, '0']
- [pad_source_0, '0', root_raised_cosine_filter_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', pad_sink_0, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [satellites_ccsds_concatenated_deframer_0_0, out, pdu_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
