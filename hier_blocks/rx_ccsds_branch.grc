options:
  parameters:
    generate_options: hb
    id: rx_ccsds_branch
    output_language: python
    run_options: run
    title: RX CCSDS Branch
  states: {}

blocks:
- name: constel
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {state: disabled}
- name: constel
  id: variable_constellation
  parameters:
    const_points: digital.psk_4()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_4()[1]
    type: calcdist
  states: {}
- name: variable_cc_decoder_def_0
  id: variable_cc_decoder_def
  parameters:
    comment: |-
      I=1; 2072
      I=5; 10232
    framebits: '16352'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,-109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: variable_cc_decoder_def_1
  id: variable_cc_decoder_def
  parameters:
    comment: |-
      I=1; 2072
      I=5; 10232
    framebits: '16352'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,-109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: variable_cc_encoder_def_0
  id: variable_cc_encoder_def
  parameters:
    comment: |-
      I=1; 2072
      I=5; 10232
    framebits: '16352'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,-109]'
    rate: '2'
    state_start: '0'
  states: {}
- name: blocks_stream_to_vector_2_0
  id: blocks_stream_to_vector
  parameters:
    comment: |-
      I=1; 223
      I=5; 1115
    num_items: '1784'
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: chess_ccsds_descrambler_rx_1
  id: chess_ccsds_descrambler_rx
  parameters: {}
  states: {}
- name: chess_fast_sync_0_0
  id: chess_fast_sync
  parameters:
    asm0: '"1ACFFC1D"'
    asm1: '"E53003E2"'
    max_misses: '1'
    payload_len: '16320'
    threshold: '0'
  states: {state: disabled}
- name: digital_constellation_soft_decoder_cf_0_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: constel
    npwr: '-1'
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: variable_cc_decoder_def_0
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: satellites_decode_rs_ccsds_0
  id: satellites_decode_rs_ccsds
  parameters:
    basis: 'True'
    interleave: '8'
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: I
  id: parameter
  parameters:
    label: I
    type: int
    value: '8'
  states: {}
- name: packet_len
  id: parameter
  parameters:
    label: packet_len
    type: int
    value: '16320'
  states: {}
- name: phase_rot
  id: parameter
  parameters:
    label: phase_rot
    type: float
    value: '0'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}

connections:
- [digital_constellation_soft_decoder_cf_0_0, '0', fec_extended_decoder_0, '0']
- [fec_extended_decoder_0, '0', blocks_tag_gate_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, satellites_decode_rs_ccsds_0, in]
- [satellites_decode_rs_ccsds_0, out, pdu_pdu_to_tagged_stream_0_0, pdus]
- [pad_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', digital_constellation_soft_decoder_cf_0_0, '0']
- [chess_ccsds_descrambler_rx_1, '0', pad_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
