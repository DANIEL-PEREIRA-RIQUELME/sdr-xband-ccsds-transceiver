options:
  parameters:
    generate_options: hb
    id: rx_soft_decoder
    output_language: python
    title: Receiver (soft decoder)
  states: {}

blocks:
- name: constel
  id: variable_constellation
  parameters:
    const_points: digital.psk_4()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: soft_decision_precision
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_4()[1]
    type: calcdist
  states: {}
- name: variable_cc_decoder_def_0
  id: variable_cc_decoder_def
  parameters:
    framebits: '2072'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,-109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: HighDataRate_Modem_Decode_RS_0
  id: HighDataRate_Modem_Decode_RS
  parameters:
    dual_basis: 'True'
    interleave: '5'
    pad: '0'
  states: {}
- name: HighDataRate_Modem_Frame_Extract_xx_0
  id: HighDataRate_Modem_Frame_Extract_xx
  parameters:
    ASM_length: '32'
    buffer_length: '15000'
    frame_length: '2072'
    type: byte
  states: {}
- name: HighDataRate_Modem_Resolve_Phase_0
  id: HighDataRate_Modem_Resolve_Phase
  parameters:
    buffer_length: '120000'
    frame_length: '2072'
    threshold: '1'
    waveform: '2'
  states: {}
- name: HighDataRate_Modem_Tag_FrameASM_xx_0
  id: HighDataRate_Modem_Tag_FrameASM_xx
  parameters:
    ASM_length: '32'
    threshold: '1'
    type: byte
    waveform: '1'
  states: {state: disabled}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    lengths: (32,2040)
    type: byte
  states: {}
- name: blocks_stream_to_vector_2_0_0
  id: blocks_stream_to_vector
  parameters:
    affinity: '3'
    num_items: '255'
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '223'
    type: byte
  states: {}
- name: chess_ccsds_descrambler_rx_1
  id: chess_ccsds_descrambler_rx
  parameters: {}
  states: {}
- name: digital_constellation_soft_decoder_cf_0_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: constel
    npwr: '-1'
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '00011010110011111111110000011101'
    tagname: TagASM
    threshold: '3'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: loop_bw_costas
  states: {}
- name: digital_pfb_clock_sync_xxx_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '0'
    loop_bw: loop_bw_sync
    max_dev: '1.5'
    osps: '1'
    sps: '2'
    taps: firdes.root_raised_cosine(32,64,1.0,0.5,1704)
    type: ccf
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: loop_bw_sync
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {state: disabled}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: variable_cc_decoder_def_0
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: loop_bw_costas
  id: parameter
  parameters:
    value: 2*3.14159/1000
  states: {}
- name: loop_bw_sync
  id: parameter
  parameters:
    value: '0.06'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_sink_0_0_0
  id: pad_sink
  parameters:
    label: sync_out
    type: complex
  states: {}
- name: pad_sink_0_0_1
  id: pad_sink
  parameters:
    label: Costas_out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: rolloff
  id: parameter
  parameters:
    value: '0.5'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: rolloff
    decim: '1'
    gain: '1'
    ntaps: '32'
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_ccf
  states: {state: disabled}
- name: samp_rate
  id: parameter
  parameters:
    value: '25000000'
  states: {}
- name: soft_decision_precision
  id: parameter
  parameters:
    value: '8'
  states: {}
- name: sps
  id: parameter
  parameters:
    value: '2'
  states: {}

connections:
- [HighDataRate_Modem_Decode_RS_0, '0', blocks_vector_to_stream_0, '0']
- [HighDataRate_Modem_Frame_Extract_xx_0, '0', HighDataRate_Modem_Resolve_Phase_0, '0']
- [HighDataRate_Modem_Resolve_Phase_0, '0', blocks_stream_demux_0, '0']
- [HighDataRate_Modem_Tag_FrameASM_xx_0, '0', HighDataRate_Modem_Frame_Extract_xx_0, '0']
- [analog_agc_xx_0, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_stream_to_vector_2_0_0, '0']
- [blocks_stream_demux_0, '0', blocks_null_sink_1, '0']
- [blocks_stream_demux_0, '1', chess_ccsds_descrambler_rx_1, '0']
- [blocks_stream_to_vector_2_0_0, '0', HighDataRate_Modem_Decode_RS_0, '0']
- [blocks_tag_gate_0, '0', HighDataRate_Modem_Tag_FrameASM_xx_0, '0']
- [blocks_tag_gate_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [blocks_vector_to_stream_0, '0', pad_sink_0, '0']
- [chess_ccsds_descrambler_rx_1, '0', blocks_pack_k_bits_bb_0_0, '0']
- [digital_constellation_soft_decoder_cf_0_0, '0', fec_extended_decoder_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', HighDataRate_Modem_Frame_Extract_xx_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_soft_decoder_cf_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', pad_sink_0_0_1, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', pad_sink_0_0_0, '0']
- [fec_extended_decoder_0, '0', blocks_tag_gate_0, '0']
- [pad_source_0, '0', analog_agc_xx_0, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
