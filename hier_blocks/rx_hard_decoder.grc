options:
  parameters:
    author: Daniel Pereira Riquelme
    generate_options: hb
    id: rx_hard_decoder
    output_language: python
    title: Receiver (hard decoder)
  states: {}

blocks:
- name: constel
  id: variable_constellation
  parameters:
    const_points: digital.psk_4()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: soft_decision_precision
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_4()[1]
    type: calcdist
  states: {}
- name: variable_cc_decoder_def_0
  id: variable_cc_decoder_def
  parameters:
    framebits: '2072'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,-109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: HighDataRate_Modem_Decode_RS_0
  id: HighDataRate_Modem_Decode_RS
  parameters:
    dual_basis: 'True'
    interleave: '5'
    pad: '0'
  states: {}
- name: HighDataRate_Modem_Frame_Extract_xx_0
  id: HighDataRate_Modem_Frame_Extract_xx
  parameters:
    ASM_length: '32'
    buffer_length: '15000'
    frame_length: '2072'
    type: byte
  states: {}
- name: HighDataRate_Modem_Resolve_Phase_0
  id: HighDataRate_Modem_Resolve_Phase
  parameters:
    buffer_length: '120000'
    frame_length: '2072'
    threshold: '1'
    waveform: '2'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2.0'
    type: float
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    lengths: (32,2040)
    type: byte
  states: {}
- name: blocks_stream_to_vector_2_0_0
  id: blocks_stream_to_vector
  parameters:
    affinity: '3'
    num_items: '255'
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '223'
    type: byte
  states: {}
- name: chess_ccsds_descrambler_rx_1
  id: chess_ccsds_descrambler_rx
  parameters: {}
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constel
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '00011010110011111111110000011101'
    tagname: TagASM
    threshold: '1'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: loop_bw_costas
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: loop_bw_sync
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: variable_cc_decoder_def_0
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: loop_bw_costas
  id: parameter
  parameters:
    value: 2*3.14159/1000
  states: {}
- name: loop_bw_sync
  id: parameter
  parameters:
    value: '0.045'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_sink_0_0_0
  id: pad_sink
  parameters:
    label: sync_out
    type: complex
  states: {}
- name: pad_sink_0_0_1
  id: pad_sink
  parameters:
    label: Costas_out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: rolloff
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: rolloff
    decim: '1'
    gain: '1'
    ntaps: '32'
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_ccf
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    value: '25000000'
  states: {}
- name: soft_decision_precision
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: sps
  id: parameter
  parameters:
    value: '2'
  states: {}

connections:
- [HighDataRate_Modem_Decode_RS_0, '0', blocks_vector_to_stream_0, '0']
- [HighDataRate_Modem_Frame_Extract_xx_0, '0', HighDataRate_Modem_Resolve_Phase_0, '0']
- [HighDataRate_Modem_Resolve_Phase_0, '0', blocks_stream_demux_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', fec_extended_decoder_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_stream_to_vector_2_0_0, '0']
- [blocks_stream_demux_0, '0', blocks_null_sink_1, '0']
- [blocks_stream_demux_0, '1', chess_ccsds_descrambler_rx_1, '0']
- [blocks_stream_to_vector_2_0_0, '0', HighDataRate_Modem_Decode_RS_0, '0']
- [blocks_tag_gate_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_vector_to_stream_0, '0', pad_sink_0, '0']
- [chess_ccsds_descrambler_rx_1, '0', blocks_pack_k_bits_bb_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', HighDataRate_Modem_Frame_Extract_xx_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0_0, '0', pad_sink_0_0_1, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_symbol_sync_xx_0, '0', pad_sink_0_0_0, '0']
- [fec_extended_decoder_0, '0', blocks_tag_gate_0, '0']
- [pad_source_0, '0', root_raised_cosine_filter_0, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
