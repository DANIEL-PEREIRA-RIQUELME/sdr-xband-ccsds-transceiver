options:
  parameters:
    generate_options: no_gui
    id: RS_CC_TX_RCV
    output_language: python
    run_options: run
    title: CCSDS X-Band Satellite Transceiver (QPSK + RS/CC, I=8)
  states: {}

blocks:
- name: altitude
  id: variable
  parameters:
    value: '475.0'
  states: {}
- name: ebn0_db
  id: variable
  parameters:
    value: '3'
  states: {}
- name: f_tx
  id: variable
  parameters:
    value: 8.4e9
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '25000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: output/samples/test/output_2m_3_50
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0_0_0_0_0
  id: blocks_file_source
  parameters:
    affinity: '1'
    file: data/32bitASM_CCSDS_only
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0_0_0_0_0
  id: blocks_file_source
  parameters:
    affinity: '1'
    file: data/test_signal_0.06Ms_CCSDS_I_8
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: ccsds_concatenated_rx_0
  id: ccsds_concatenated_rx
  parameters:
    interleave: '8'
    loop_bw: '0.002'
    max_missed: '1'
    rolloff: '0.5'
    samp_rate: '25000000'
    sps: '2'
    sync_threshold: '0'
  states: {}
- name: ccsds_concatenated_tx_0
  id: ccsds_concatenated_tx
  parameters:
    interleave: '8'
    rolloff: '0.5'
    samp_rate: '25000000'
    sps: '2'
  states: {}
- name: chess_coarse_doppler_sync_0
  id: chess_coarse_doppler_sync
  parameters:
    alpha: '0.7'
    comment: decim=8, fft_len=16384 → bin=190 Hz → residual ±95 Hz < Costas capture range
    correct_freq: 'True'
    decim: '8'
    fft_len: '16384'
    m_order: '4'
    samp_rate: samp_rate
    threshold_db: '1.0'
    update_interval: '131072'
  states: {}
- name: chess_doppler_channel_0
  id: chess_doppler_channel
  parameters:
    f_tx: 10.475e9
    noise_voltage: math.sqrt(sps / (10**(ebn0_db / 10.0) * (223.0/259.0)))
    rx_alt: '478.0'
    rx_inc: '52.5'
    rx_max_el: '91'
    samp_rate: samp_rate
    tx_alt: '475.0'
    tx_inc: '53.0'
    tx_max_el: '90.0'
  states: {state: disabled}
- name: chess_downlink_channel_0
  id: chess_downlink_channel
  parameters:
    altitude: '475'
    f_carrier: 8.4e9
    inclination: '53.0'
    max_el: '90.0'
    noise_voltage: math.sqrt(sps / (10**(ebn0_db / 10.0) * (223.0/259.0)))
    samp_rate: samp_rate
    t_offset: '-150.0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}

connections:
- [blocks_file_source_0_0_0_0_0, '0', ccsds_concatenated_tx_0, '1']
- [blocks_file_source_0_0_0_0_0_0, '0', ccsds_concatenated_tx_0, '0']
- [blocks_throttle2_0, '0', chess_downlink_channel_0, '0']
- [ccsds_concatenated_rx_0, '0', blocks_file_sink_0, '0']
- [ccsds_concatenated_rx_0, '1', blocks_null_sink_0, '0']
- [ccsds_concatenated_rx_0, '1', qtgui_const_sink_x_0, '0']
- [ccsds_concatenated_tx_0, '0', blocks_throttle2_0, '0']
- [chess_coarse_doppler_sync_0, '0', ccsds_concatenated_rx_0, '0']
- [chess_downlink_channel_0, '0', chess_coarse_doppler_sync_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
