options:
  parameters:
    generate_options: qt_gui
    id: RS_CC_TX_RCV
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: altitude
  id: variable
  parameters:
    value: '475.0'
  states: {}
- name: constel
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {state: disabled}
- name: constel
  id: variable_constellation
  parameters:
    const_points: digital.psk_4()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_4()[1]
    type: calcdist
  states: {}
- name: ebn0_db
  id: variable
  parameters:
    value: '4'
  states: {}
- name: f_tx
  id: variable
  parameters:
    value: 8.4e9
  states: {}
- name: phase_idx
  id: variable_qtgui_chooser
  parameters:
    labels: '[''0º'', ''90º'', ''180º'', ''270º'']'
    num_opts: '0'
    options: '[0, 1, 2, 3]'
    type: int
    value: '0'
  states: {state: disabled}
- name: rolloff
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '25000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: variable_cc_decoder_def_0
  id: variable_cc_decoder_def
  parameters:
    comment: |-
      I=1; 2072
      I=5; 10232
    framebits: '2072'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,-109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: variable_cc_encoder_def_0
  id: variable_cc_encoder_def
  parameters:
    comment: |-
      I=1; 2072
      I=5; 10232
    framebits: '2072'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,-109]'
    rate: '2'
    state_start: '0'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '2000000'
    freq: '0.001'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: samples/single/output_SNR_4_00
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: samples/doppler_soft_5m/output_SNR_freq
    type: float
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: samples/doppler_soft_5m/output_SNR_channel
    type: complex
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_source_0_0_0_0_0
  id: blocks_file_source
  parameters:
    affinity: '1'
    file: data/32bitASM_CCSDS_only
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0_0_0_0_0
  id: blocks_file_source
  parameters:
    affinity: '1'
    file: data/test_signal_0.3Ms_CCSDS
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1j**phase_idx
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '2'
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    comment: |-
      I=1; (32, 2040)
      I=5; (32, 10200)
    lengths: (32, 2040)
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: |-
      I=1; 255
      I=5; 1275
    len_tag_key: '"packet_len"'
    packet_len: '255'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: |-
      I=1; 223
      I=5; 1115
    len_tag_key: '"packet_len"'
    packet_len: '223'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_1
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: |-
      I=1; 2040
      I=5; 10200
    len_tag_key: '"packet_len"'
    packet_len: '2040'
    type: byte
  states: {}
- name: blocks_stream_to_vector_2_0
  id: blocks_stream_to_vector
  parameters:
    comment: |-
      I=1; 223
      I=5; 1115
    num_items: '223'
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: 2 * math.pi
  states: {state: disabled}
- name: blocks_vector_to_stream_0_1
  id: blocks_vector_to_stream
  parameters:
    comment: |-
      I=1; 255
      I=5; 1275
    num_items: '255'
    type: byte
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: math.sqrt(sps / (10**(ebn0_db / 10.0) * (223.0/259.0)))
    seed: '0'
    taps: '1.0'
  states: {state: disabled}
- name: chess_async_rotator_0
  id: chess_async_rotator
  parameters: {}
  states: {}
- name: chess_ccsds_descrambler_rx_1
  id: chess_ccsds_descrambler_rx
  parameters: {}
  states: {}
- name: chess_ccsds_scrambler_tx_0
  id: chess_ccsds_scrambler_tx
  parameters: {}
  states: {}
- name: chess_doppler_channel_0
  id: chess_doppler_channel
  parameters:
    f_tx: 10.475e9
    noise_voltage: math.sqrt(sps / (10**(ebn0_db / 10.0) * (223.0/259.0)))
    rx_alt: '486.0'
    rx_inc: '54.0'
    rx_max_el: '94.0'
    samp_rate: samp_rate
    tx_alt: '475.0'
    tx_inc: '53.0'
    tx_max_el: '90.0'
  states: {state: disabled}
- name: chess_encode_rs_1
  id: chess_encode_rs
  parameters:
    comment: |-
      I=1; 223
      I=5; 1115
    dual_basis: 'True'
    frame_size: '223'
    interleave: '1'
  states: {}
- name: chess_fast_sync_0
  id: chess_fast_sync
  parameters:
    loop_bw: '0.05'
    nfilters: '32'
    sync_type: '1'
    taps: firdes.root_raised_cosine(32, 64, 1.0, 0.5, 1704)
  states: {state: disabled}
- name: chess_flywheel_sync_0
  id: chess_flywheel_sync
  parameters:
    asm0: '"1ACFFC1D"'
    asm1: '"E53003E2"'
    comment: |-
      I=1; 2040
      I=5; 10200
    max_misses: '1'
    payload_len: '2040'
    threshold: '1'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: constel.points()
  states: {}
- name: digital_constellation_soft_decoder_cf_0_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: constel
    npwr: '-1'
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '0.005'
  states: {}
- name: digital_pfb_clock_sync_xxx_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '0'
    loop_bw: '0.005'
    max_dev: '1.5'
    osps: '1'
    sps: '2'
    taps: firdes.root_raised_cosine(32,64,1.0,0.5,1704)
    type: ccf
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.004'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {state: disabled}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class rx_pure_doppler_injector(gr.sync_block):
          def __init__(self, samp_rate=1000000.0, f_tx=8.4e9, duration=600.0, 
                       altitude_km=475.0, max_elevation_deg=90.0, inclination_deg=53.0):
              """
              Inyector rápido de Doppler puro basado en Ali et al. (1998) Eq. 5.
              """
              gr.sync_block.__init__(
                  self, 
                  name='RX Pure Doppler Injector', 
                  in_sig=[np.complex64], 
                  out_sig=[np.complex64]
              )
              self.samp_rate = samp_rate
              self.count = 0
              self.phase_acc = 0.0
              
              # Precalculamos el Doppler a 10 Hz (10 actualizaciones por segundo es suficiente)
              self.lut_rate = 10.0 
              n_points = int(duration * self.lut_rate)
              t_array = np.linspace(-duration/2, duration/2, n_points)
              
              # Constantes de Astrodinámica
              r_E = 6371.0
              c_km_s = 299792.458
              mu = 398600.44
              r = r_E + altitude_km
              
              # Eq 8 & 9: Velocidad angular aproximada en el marco ECF
              omega_s = np.sqrt(mu / (r**3))
              omega_E = 7.292115e-5
              omega_F = omega_s - omega_E * np.cos(np.radians(inclination_deg))
              
              # Eq 4: Ángulo central en epoch
              theta_max = np.radians(max_elevation_deg)
              gamma_t0 = np.arccos((r_E/r) * np.cos(theta_max)) - theta_max
              cos_gamma_t0 = np.cos(gamma_t0)
              
              # Eq 5: Fórmula analítica del Doppler
              psi_diff = omega_F * t_array
              num = r_E * r * np.sin(psi_diff) * cos_gamma_t0 * omega_F
              den = np.sqrt(r_E**2 + r**2 - 2 * r_E * r * np.cos(psi_diff) * cos_gamma_t0)
              
              # Frecuencia real en Hz que "siente" el receptor (lleva signo negativo)
              self.freq_lut = -(f_tx * (num / den) / c_km_s)

          def work(self, input_items, output_items):
              n = len(input_items[0])
              
              # Buscar la frecuencia en la LUT basándose en el tiempo de simulación
              t_sec = self.count / self.samp_rate
              idx = int(t_sec * self.lut_rate)
              if idx >= len(self.freq_lut): 
                  idx = -1 # Mantiene el último valor si nos pasamos del tiempo
                  
              f_hz = self.freq_lut[idx]
              
              # Multiplicación vectorial masiva en C (Súper rápido)
              phase_step = 2.0 * np.pi * f_hz / self.samp_rate
              phases = self.phase_acc + np.arange(1, n + 1) * phase_step
              
              output_items[0][:] = input_items[0] * np.exp(1j * phases)
              self.phase_acc = phases[-1] % (2 * np.pi)
              self.count += n
              
              return n
    altitude_km: '512'
    duration: '175'
    f_tx: f_tx
    inclination_deg: '53.0'
    max_elevation_deg: '90.0'
    samp_rate: samp_rate
  states: {state: disabled}
- name: epy_block_1_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class tx_analytic_precorrector(gr.sync_block):
          def __init__(self, samp_rate=1000000.0, f_tx=8.4e9, duration=600.0, 
                       altitude_km=475.0, max_elevation_deg=90.0, inclination_deg=53.0):
              """
              TX Pre-corrector basado en Ali et al. (1998) Eq. 5.
              Aplica el Doppler inverso para contrarrestar la física.
              """
              gr.sync_block.__init__(
                  self, 
                  name='TX Doppler Pre-Corrector', 
                  in_sig=[np.complex64], 
                  out_sig=[np.complex64]
              )
              self.samp_rate = samp_rate
              self.count = 0
              self.phase_acc = 0.0
              self.lut_rate = 10.0
              
              n_points = int(duration * self.lut_rate)
              t_array = np.linspace(-duration/2, duration/2, n_points)
              
              # Constantes
              r_E = 6371.0
              c_km_s = 299792.458
              mu = 398600.44
              r = r_E + altitude_km
              
              omega_s = np.sqrt(mu / (r**3))
              omega_E = 7.292115e-5
              omega_F = omega_s - omega_E * np.cos(np.radians(inclination_deg))
              
              theta_max = np.radians(max_elevation_deg)
              gamma_t0 = np.arccos((r_E/r) * np.cos(theta_max)) - theta_max
              cos_gamma_t0 = np.cos(gamma_t0)
              
              psi_diff = omega_F * t_array
              num = r_E * r * np.sin(psi_diff) * cos_gamma_t0 * omega_F
              den = np.sqrt(r_E**2 + r**2 - 2 * r_E * r * np.cos(psi_diff) * cos_gamma_t0)
              
              # NOTA EL CAMBIO DE SIGNO AQUÍ: Es positivo para pre-cancelar
              self.freq_lut = (f_tx * (num / den) / c_km_s)

          def work(self, input_items, output_items):
              n = len(input_items[0])
              
              t_sec = self.count / self.samp_rate
              idx = int(t_sec * self.lut_rate)
              if idx >= len(self.freq_lut): 
                  idx = -1
                  
              f_hz = self.freq_lut[idx]
              
              phase_step = 2.0 * np.pi * f_hz / self.samp_rate
              phases = self.phase_acc + np.arange(1, n + 1) * phase_step
              
              output_items[0][:] = input_items[0] * np.exp(1j * phases)
              self.phase_acc = phases[-1] % (2 * np.pi)
              self.count += n
              
              return n
    altitude_km: altitude
    duration: '175'
    f_tx: f_tx
    inclination_deg: '53.0'
    max_elevation_deg: '90.0'
    samp_rate: samp_rate
  states: {state: disabled}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: variable_cc_decoder_def_0
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: fec_extended_encoder_0
  id: fec_extended_encoder
  parameters:
    encoder_list: variable_cc_encoder_def_0
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '10'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Signal source"'
    size: '1000'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: rolloff
    decim: '1'
    gain: '1'
    ntaps: '32'
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_ccf
  states: {state: disabled}
- name: root_raised_cosine_filter_0_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: rolloff
    gain: sps
    interp: '2'
    ntaps: '32'
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: interp_fir_filter_ccf
  states: {}
- name: satellites_decode_rs_ccsds_0
  id: satellites_decode_rs_ccsds
  parameters:
    basis: 'True'
    interleave: '1'
  states: {}

connections:
- [analog_agc_xx_0, '0', chess_fast_sync_0, '0']
- [analog_agc_xx_0, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [analog_agc_xx_0, '0', root_raised_cosine_filter_0, '0']
- [analog_sig_source_x_0, '0', blocks_vco_c_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_file_source_0_0_0_0_0, '0', blocks_stream_mux_0, '0']
- [blocks_file_source_0_0_0_0_0_0, '0', blocks_stream_to_tagged_stream_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', chess_async_rotator_0, '0']
- [blocks_multiply_xx_0_0, '0', chess_doppler_channel_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_stream_mux_0, '0', fec_extended_encoder_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0, '0', blocks_stream_to_vector_2_0, '0']
- [blocks_stream_to_tagged_stream_0_0_1, '0', chess_ccsds_scrambler_tx_0, '0']
- [blocks_stream_to_vector_2_0, '0', chess_encode_rs_1, '0']
- [blocks_tag_gate_0, '0', chess_flywheel_sync_0, '0']
- [blocks_throttle2_0, '0', analog_agc_xx_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_throttle2_0, '0', chess_doppler_channel_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0_0_0, '0', blocks_stream_to_tagged_stream_0_0_1, '0']
- [blocks_vco_c_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_vector_to_stream_0_1, '0', blocks_unpack_k_bits_bb_0_0_0_0_0, '0']
- [channels_channel_model_0_0, '0', epy_block_1_0, '0']
- [chess_async_rotator_0, '0', digital_constellation_soft_decoder_cf_0_0, '0']
- [chess_ccsds_descrambler_rx_1, '0', blocks_pack_k_bits_bb_0_0, '0']
- [chess_ccsds_scrambler_tx_0, '0', blocks_stream_mux_0, '1']
- [chess_doppler_channel_0, '0', analog_agc_xx_0, '0']
- [chess_doppler_channel_0, '0', blocks_file_sink_0_0_0, '0']
- [chess_encode_rs_1, '0', blocks_vector_to_stream_0_1, '0']
- [chess_fast_sync_0, '0', digital_costas_loop_cc_0_0, '0']
- [chess_flywheel_sync_0, '0', chess_ccsds_descrambler_rx_1, '0']
- [chess_flywheel_sync_0, rotate_cmd, chess_async_rotator_0, rotate_in]
- [digital_chunks_to_symbols_xx_0, '0', root_raised_cosine_filter_0_0_0, '0']
- [digital_constellation_soft_decoder_cf_0_0, '0', fec_extended_decoder_0, '0']
- [digital_costas_loop_cc_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_costas_loop_cc_0_0, '0', chess_async_rotator_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0_0, '1', blocks_file_sink_0_0, '0']
- [digital_costas_loop_cc_0_0, '1', qtgui_time_sink_x_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0_0, '0']
- [epy_block_1_0_0, '0', channels_channel_model_0_0, '0']
- [epy_block_1_0_0, '0', qtgui_freq_sink_x_0, '0']
- [fec_extended_decoder_0, '0', blocks_tag_gate_0, '0']
- [fec_extended_encoder_0, '0', blocks_pack_k_bits_bb_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_file_sink_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_null_sink_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, satellites_decode_rs_ccsds_0, in]
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [root_raised_cosine_filter_0_0_0, '0', blocks_throttle2_0, '0']
- [satellites_decode_rs_ccsds_0, out, pdu_pdu_to_tagged_stream_0_0, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
