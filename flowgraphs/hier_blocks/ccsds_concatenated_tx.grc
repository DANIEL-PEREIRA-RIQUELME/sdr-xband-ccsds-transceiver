options:
  parameters:
    category: '[CHESS]/S-X Band/Hier Blocks'
    generate_options: hb
    id: ccsds_concatenated_tx
    output_language: python
    title: CCSDS Transmitter (QPSK + RS/CC)
  states: {}

blocks:
- name: constel
  id: variable_constellation
  parameters:
    const_points: digital.psk_4()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_4()[1]
    type: calcdist
  states: {}
- name: variable_cc_encoder_def_0
  id: variable_cc_encoder_def
  parameters:
    framebits: '16352'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,-109]'
    rate: '2'
    state_start: '0'
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '2'
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    comment: |-
      I=1; (32, 2040)
      I=5; (32, 10200)
    lengths: (32, 16320)
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: |-
      I=1; 223
      I=5; 1115
    len_tag_key: '"packet_len"'
    packet_len: '1784'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_1
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: |-
      I=1; 2040
      I=5; 10200
    len_tag_key: '"packet_len"'
    packet_len: '16320'
    type: byte
  states: {}
- name: blocks_stream_to_vector_2_0
  id: blocks_stream_to_vector
  parameters:
    comment: |-
      I=1; 223
      I=5; 1115
    num_items: '1784'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_to_stream_0_1
  id: blocks_vector_to_stream
  parameters:
    comment: |-
      I=1; 255
      I=5; 1275
    num_items: '2040'
    type: byte
  states: {}
- name: chess_ccsds_scrambler_tx_0
  id: chess_ccsds_scrambler_tx
  parameters: {}
  states: {}
- name: chess_encode_rs_1
  id: chess_encode_rs
  parameters:
    comment: |-
      I=1; 223
      I=5; 1115
    dual_basis: 'True'
    frame_size: '1784'
    interleave: interleave
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: constel.points()
  states: {}
- name: fec_extended_encoder_0
  id: fec_extended_encoder
  parameters:
    encoder_list: variable_cc_encoder_def_0
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: interleave
  id: parameter
  parameters:
    label: Interleave
    value: '8'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: tx_signal
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: Source
    type: byte
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: ASM
    type: byte
  states: {}
- name: rolloff
  id: parameter
  parameters:
    label: Rolloff Parameter
    type: eng_float
    value: '0.5'
  states: {}
- name: root_raised_cosine_filter_0_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: rolloff
    gain: sps
    interp: '2'
    ntaps: '32'
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: interp_fir_filter_ccf
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sampling Rate
    value: '25000000'
  states: {}
- name: sps
  id: parameter
  parameters:
    label: Simbols per Sample
    value: '2'
  states: {}

connections:
- [blocks_pack_k_bits_bb_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_stream_mux_0, '0', fec_extended_encoder_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0, '0', blocks_stream_to_vector_2_0, '0']
- [blocks_stream_to_tagged_stream_0_0_1, '0', chess_ccsds_scrambler_tx_0, '0']
- [blocks_stream_to_vector_2_0, '0', chess_encode_rs_1, '0']
- [blocks_unpack_k_bits_bb_0_0_0_0_0, '0', blocks_stream_to_tagged_stream_0_0_1, '0']
- [blocks_vector_to_stream_0_1, '0', blocks_unpack_k_bits_bb_0_0_0_0_0, '0']
- [chess_ccsds_scrambler_tx_0, '0', blocks_stream_mux_0, '1']
- [chess_encode_rs_1, '0', blocks_vector_to_stream_0_1, '0']
- [digital_chunks_to_symbols_xx_0, '0', root_raised_cosine_filter_0_0_0, '0']
- [fec_extended_encoder_0, '0', blocks_pack_k_bits_bb_0, '0']
- [pad_source_0, '0', blocks_stream_to_tagged_stream_0_0_0, '0']
- [pad_source_0_0, '0', blocks_stream_mux_0, '0']
- [root_raised_cosine_filter_0_0_0, '0', pad_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
