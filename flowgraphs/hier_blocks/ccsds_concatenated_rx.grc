options:
  parameters:
    category: '[CHESS]/S-X Band/Hier Blocks'
    generate_options: hb
    id: ccsds_concatenated_rx
    output_language: python
    title: CCSDS Receiver (QPSK + RS/CC)
  states: {}

blocks:
- name: constel
  id: variable_constellation
  parameters:
    const_points: digital.psk_4()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_4()[1]
    type: calcdist
  states: {}
- name: variable_cc_decoder_def_0
  id: variable_cc_decoder_def
  parameters:
    comment: |-
      I=1; 2072
      I=5; 10232
    framebits: '16352'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,-109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: variable_cc_decoder_def_1
  id: variable_cc_decoder_def
  parameters:
    comment: |-
      I=1; 2072
      I=5; 10232
    framebits: '16352'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,-109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1j
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: |-
      I=1; 255
      I=5; 1275
    len_tag_key: '"packet_len"'
    packet_len: '2040'
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tag_gate_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: chess_ccsds_descrambler_rx_1
  id: chess_ccsds_descrambler_rx
  parameters: {}
  states: {}
- name: chess_fast_sync_0
  id: chess_fast_sync
  parameters:
    asm0: '"1ACFFC1D"'
    asm1: '"E53003E2"'
    max_misses: '1'
    payload_len: '16320'
    threshold: '0'
  states: {}
- name: digital_constellation_soft_decoder_cf_0_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: constel
    npwr: '-1'
  states: {}
- name: digital_constellation_soft_decoder_cf_0_0_1
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: constel
    npwr: '-1'
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: loop_bw
  states: {}
- name: digital_pfb_clock_sync_xxx_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '0'
    loop_bw: '0.005'
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: firdes.root_raised_cosine(32,64,1.0,0.5,1704)
    type: ccf
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: variable_cc_decoder_def_0
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: fec_extended_decoder_0_1
  id: fec_extended_decoder
  parameters:
    decoder_list: variable_cc_decoder_def_1
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: interleave
  id: parameter
  parameters:
    label: Interleave
    value: '8'
  states: {}
- name: loop_bw
  id: parameter
  parameters:
    label: Loop Bandwidth
    value: '0.002'
  states: {}
- name: max_missed
  id: parameter
  parameters:
    label: Max Missed Syncs
    value: '1'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: out_costas
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: rx_signal
    type: complex
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: rolloff
  id: parameter
  parameters:
    label: Rolloff Parameter
    type: eng_float
    value: '0.5'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sampling Rate
    value: '25000000'
  states: {}
- name: satellites_decode_rs_ccsds_0
  id: satellites_decode_rs_ccsds
  parameters:
    basis: 'True'
    interleave: interleave
  states: {}
- name: sps
  id: parameter
  parameters:
    label: Simbols per Sample
    value: '2'
  states: {}
- name: sync_threshold
  id: parameter
  parameters:
    label: Sync Threshold
    value: '0'
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', digital_constellation_soft_decoder_cf_0_0_1, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_tag_gate_0, '0', chess_fast_sync_0, '0']
- [blocks_tag_gate_0_0, '0', chess_fast_sync_0, '1']
- [chess_ccsds_descrambler_rx_1, '0', blocks_pack_k_bits_bb_0_0, '0']
- [chess_fast_sync_0, '0', chess_ccsds_descrambler_rx_1, '0']
- [digital_constellation_soft_decoder_cf_0_0, '0', fec_extended_decoder_0, '0']
- [digital_constellation_soft_decoder_cf_0_0_1, '0', fec_extended_decoder_0_1, '0']
- [digital_costas_loop_cc_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_soft_decoder_cf_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', pad_sink_0_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [fec_extended_decoder_0, '0', blocks_tag_gate_0, '0']
- [fec_extended_decoder_0_1, '0', blocks_tag_gate_0_0, '0']
- [pad_source_0, '0', analog_agc_xx_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', pad_sink_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, satellites_decode_rs_ccsds_0, in]
- [satellites_decode_rs_ccsds_0, out, pdu_pdu_to_tagged_stream_0_0, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
